# Keil uVision project WIFI_BT.uvproj, settings and files
target WIFI_BT (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: WIFI_BT +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Lib\inc;.\System;.\USR
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ASM
    ./ASM/: startup_stm32f10x_hd.s
  group USR
    ./USR/: main.c pbdata.c stm32f10x_it.c USART.c ESP8285.c RTC.c
  group Lib
    ./Lib/SRC/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c
  group System
    ./System/: core_cm3.c system_stm32f10x.c
